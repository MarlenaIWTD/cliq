# Keil uVision project swiatelka.Target_1.uvprojx, settings and files
target Target_1 (6160000::V6.16::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: swiatelka
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: __EVAL
  c misc: -Wno-documentation -Wno-documentation-unknown-command -Wno-license-management -Wno-missing-noreturn -Wno-missing-prototypes -Wno-missing-variable-declarations -Wno-nonportable-include-path -Wno-packed -Wno-parentheses-equality -Wno-reserved-id-macro -Wno-unused-macros -gdwarf-4 -xc
  asm define: __EVAL
  memory RVCT4: RAM 0x0 size 0x8000
  memory RVCT9: ROM 0x1ffffc00 size 0x1000
  link misc: --entry 0x00000000 --entry Reset_Handler --first __Vectors --summary_stderr --info summarysizes --load_addr_map_info
  group src
    ./: main.c pit.c tsi.c i2c.c tpm.c ADC.c buttons.c
  group inc
    ./: pit.h tsi.h i2c.h tpm.h frdm_bsp.h ADC.h buttons.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
