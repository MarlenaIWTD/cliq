# Keil uVision project swiatelka.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: swiatelka
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c pit.c tsi.c i2c.c tpm.c ADC.c buttons.c
  group inc
    ./: pit.h tsi.h i2c.h tpm.h frdm_bsp.h ADC.h buttons.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
